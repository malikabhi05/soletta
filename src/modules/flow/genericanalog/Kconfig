## src/modules/flow/genericanalog/Kconfig
```kconfig
config FLOW_NODE_TYPE_GENERICANALOG
	tristate "Node type: genericanalog"
	depends on USE_AIO
	default m
```
